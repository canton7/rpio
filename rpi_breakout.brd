# Repository canton7/rpio

## EAGLE design rpi_breakout.brd

Parts:
C1: 0.1uF; 0805
C2, C3: 10uF; EIA3216
JP1: RPI; 2X13
JP3, JP4: M06FEMALE_LOCK; 1X06_FEMALE_LOCK.010
JP5: IO-PWR-EXT; 1X02
JP6: VTG-SEL; 1X03
JP7, JP8: PINHD-1X1CB; 1X01-CLEANBIG
LED1: CONNECTED; CHIPLED_0805
LED2: IO-POWER; CHIPLED_0805
LED3, LED4: BLINKY; CHIPLED_0805
R1, R2, R3, R4: 330; 0805
U2, U3: TXB0108PWR; TSSOP20
VREG1: 3.3V; SOT-23-5

Connections:
3.3V: C1.1, C2.A (+), JP3.3, JP6.1, VREG1.5 (OUT)
3V3_RPI: JP1.1, U2.2 (VCCA), U2.10 (OE), U3.2 (VCCA), U3.10 (OE)
5V: JP6.3, R1.1, VREG1.1 (IN), VREG1.3 (EN)
5V0: JP1.2
/SPI_CE0: JP1.24, U2.3 (A2)
/SPI_CE1: JP1.26, JP4.6
/SPI_CEV0: JP4.5, U2.18 (B2)
GND: C1.2, C2.C (-), C3.C (-), JP1.6, JP3.2, JP5.2, LED1.C, LED2.C, R3.2, R4.2, U2.11 (GND), U3.11 (GND), VREG1.2 (GND)
GPIOV_0: U3.17 (B3); also elsewhere on the board
GPIOV_1: U3.18 (B2); also elsewhere on the board
GPIOV_2: U3.20 (B1); also elsewhere on the board
GPIOV_3: U2.13 (B7); also elsewhere on the board
GPIOV_4: U2.12 (B8); also elsewhere on the board
GPIOV_5: U2.14 (B6); also elsewhere on the board
GPIOV_6: U2.16 (B4); also elsewhere on the board
GPIOV_7: U3.14 (B6); also elsewhere on the board
GPIO_0: JP1.11, U3.4 (A3)
GPIO_1: JP1.12, U3.3 (A2)
GPIO_2: JP1.13, U3.1 (A1)
GPIO_3: JP1.15, U2.8 (A7)
GPIO_4: JP1.16, U2.9 (A8)
GPIO_5: JP1.18, U2.7 (A6)
GPIO_6: JP1.22, U2.5 (A4)
GPIO_7: JP1.7, U3.7 (A6)
LED3_JP: JP7.1, LED3.A
LED4_JP: JP8.1, LED4.A
unnamed: LED1.A, R1.2
unnamed: LED2.A, R2.2
unnamed: LED3.C, R3.1
unnamed: LED4.C, R4.1
NC_0: JP1.4
NC_1: JP1.14
NC_2: JP1.20
NC_3: JP1.9
NC_4: JP1.17
NC_5: JP1.25
RXD: JP1.10, U3.5 (A4)
RXDV: JP4.1, U3.16 (B4)
SCL0: JP1.5, U3.8 (A7)
SCLV0: JP3.5, U3.13 (B7)
SDA0: JP1.3, U3.9 (A8)
SDAV0: JP3.4, U3.12 (B8)
SPI_MISO: JP1.21, U2.4 (A3)
SPI_MISOV: JP4.3, U2.17 (B3)
SPI_MOSI: JP1.19, U2.6 (A5)
SPI_MOSIV: JP4.2, U2.15 (B5)
SPI_SCLK: JP1.23, U2.1 (A1)
SPI_SCLKV: JP4.4, U2.20 (B1)
TXD: JP1.8, U3.6 (A5)
TXDV: JP3.6, U3.15 (B5)
VCC: C3.A (+), JP3.1, JP5.1, JP6.2, R2.1, U2.19 (VCCB), U3.19 (VCCB)

Notes on the sheet:
Breakouts
Power
Blinkenlights
Level Translation
A Raspberry Pi GPIO level shifter.
www.sowbug.com
DANGER! SPI_CE1 is not shifted!

Board: 2 copper layers, 36.8 x 34.3 mm, 22 parts (0 on the bottom side), 44 nets.

Other parts of the board:
JP2: GPIO; 1X08_LOCK

Their connections:
GPIOV_0: JP2.1; also elsewhere on the board
GPIOV_1: JP2.2; also elsewhere on the board
GPIOV_2: JP2.3; also elsewhere on the board
GPIOV_3: JP2.4; also elsewhere on the board
GPIOV_4: JP2.5; also elsewhere on the board
GPIOV_5: JP2.6; also elsewhere on the board
GPIOV_6: JP2.7; also elsewhere on the board
GPIOV_7: JP2.8; also elsewhere on the board

## Commit log

2012-03-13 Add level shifter to custom library, and make pins swappable
2012-03-13 Add gitignore
2012-03-13 Much nicer routing, with the help of peterobinson
2012-03-13 Update images
2012-03-13 Tidy up a little bit of the routing
2012-03-13 Oops, fix a duplicate ground connection

Notices in the files:
parts and their libraries:
SparkFun: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
